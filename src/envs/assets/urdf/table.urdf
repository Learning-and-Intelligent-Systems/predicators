Commit message: change table size

File: src/envs/assets/urdf/table.urdf (robot description, URDF)
Before this commit: robot table, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.5 0.9 0.4; visual box size=0.5 0.9 0.4
