Commit message: wip

File: predicators/envs/assets/urdf/comm_vessel2.urdf (robot description, URDF)
Before this commit: robot communicating_vessels, 1 links, 0 joints
Links:
- link vessels_link: geometry collision box size=0.01 0.025 0.05; collision box size=0.01 0.025 0.05
