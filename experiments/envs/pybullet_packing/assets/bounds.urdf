Commit message: scale env, moved old envs

File: experiments/envs/pybullet_packing/assets/bounds.urdf (robot description, URDF)
Before this commit: robot bounds, 1 links, 0 joints
Links:
- link baseLink: geometry collision mesh filename=bounds-collision.obj; visual mesh filename=bounds.obj
